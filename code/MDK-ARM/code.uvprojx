# Keil uVision project code.uvprojx, settings and files
target code (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G031C8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800F7FF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: code +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G031xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../code/ad7682;../code/battery;../code/sht41;../code/w25q128;../code/pcf8563;../code/lps22hh;../code/data_logger;../code/oled;../code/uart_crc
  memory RVCT4: ROM 0x8000000 size 0xf800
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g031xx.s
  group Application/User/Core
    ../Core/Src/: i2c.c main.c gpio.c adc.c spi.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Application/User/Drivers
    ../code/ad7682/: ad7682.c
    ../code/battery/: battery_adc.c
    ../code/sht41/: sht41.c
    ../code/w25q128/: w25q128.c
    ../code/oled/: ssd1306.c
    ../code/pcf8563/: pcf8563.c
    ../code/lps22hh/: lps22hh.c
    ../code/uart_crc/: uart_crc.c
    ../code/data_logger/: data_logger.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
software components: CMSIS:CORE 4.3.0
